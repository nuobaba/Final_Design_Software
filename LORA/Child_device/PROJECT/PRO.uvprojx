# Keil uVision project PRO.uvprojx, settings and files
target PRO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PRO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\DRIVER;..\STLibraries\inc;..\USR;..\DRIVER\Ds18b20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USR
    ../USR/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DRIVER
    ../DRIVER/UART/: uart.c
    ../DRIVER/DELAY/: Delay.c
    ../DRIVER/ADC/: ADC.c
    ../DRIVER/LED/: LED.c LED.h
    ../DRIVER/IIC/: IIC.c IIC.h
    ../DRIVER/OLED/: BMP.h FONT.h OLED.c OLED.h
    ../DRIVER/SX1278/: SX1278.c SX1278.h
    ../DRIVER/SPIx/: SPIx.c SPIx.h
    ../DRIVER/Ds18b20/: Ds18b20.c Ds18b20.h
  group STLibraries
    ../STLibraries/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group DOC
    ../DOC/: doc.txt
